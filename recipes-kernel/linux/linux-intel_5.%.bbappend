FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://joystic.cfg"
